Commit message: change source

File: urdf/kr210l150.urdf (robot description, URDF)
Before this commit: robot kuka_kr210, 10 links, 8 joints
Links:
- removed link rail_link
Joints:
- joint world_fixed: child rail_link -> base_link
